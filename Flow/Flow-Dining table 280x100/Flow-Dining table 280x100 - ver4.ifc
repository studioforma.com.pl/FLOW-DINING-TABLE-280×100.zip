Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Flow-Dining table 280x100 - ver4.ifc
Time: 2025-11-11T17:52:00
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (6)
Name
 | Flow-Dining table 280x100_0 - ObjectType: SketchupGroup
 | Flow-Dining table 280x100_1 - ObjectType: SketchupGroup
 | Flow-Dining table 280x100_2 - ObjectType: SketchupGroup
 | Flow-Dining table 280x100_3 - ObjectType: SketchupGroup
 | Flow-Dining table 280x100_4 - ObjectType: SketchupGroup
 | Flow-Dining table 280x100_5 - ObjectType: SketchupGroup
